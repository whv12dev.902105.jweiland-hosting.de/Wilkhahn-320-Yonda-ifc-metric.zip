Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [Design_Transfer_View], ExchangeRequirement [Architecture], Option [Drawing Scale: 100.000000], Option [Elements to export: Selected elements only], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and ARCHICAD 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Export geometries that Participates in Collision Detection only: On], Option [Split complex elements: Off], Option [Material Preservation: Explode where necessary], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [Slabs with slanted edge(s): Extruded], Option [IFC Site Location: At Project Origin], Option [Curtain Wall export mode: Single Element], Option [Railing export mode: Single Element], Option [Stair export mode: Single Element], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Bounding Box: Off], Option [Geometry to type objects: Off], Option [Element Properties: Off], Option [Building Material Properties: Off], Option [Element Parameters: Off], Option [Component Parameters: Off], Option [IFC Base Quantities: Off], Option [Door Window Parameters: On], Option [IFC Space boundaries: Off], Option [ARCHICAD Zone Categories as IFC Space classification data: Off], Option [Element Classifications: On]
File name: K:\@PROJEKTE\Wilkhahn\Internetdaten\IFC\Wilkhahn-320-Yonda-ifc-metric\Wilkhahn-0032030-Yonda-castors-ifc-metric.ifc
Time: 2023-08-07T13:09:19
Author: Architect
Organization: Building Designer Office
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: IFC file generated by GRAPHISOFT ARCHICAD 24.0.0 GER FULL Windows version (IFC add-on version: 3008 GER FULL).
Authorization: The authorising person

# IfcSite, Gelände
RefLatitude: 52, 31, 0, 0; RefLongitude: 13, 24, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, EG
In: Gebäude
Elevation: 0 m

# IfcBuildingElementProxy: 320 Yonda, Stuhl-001
In: EG
Pset_BuildingElementProxyCommon - LoadBearing: no; IsExternal: no; Status: EXISTING
